# IAR project generated.ewp, settings and files
configuration generated (ARM, debug)
  General.OGChipSelectEditMenu: STM32F050x4 ST STM32F050x4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32F030x6; USE_FULL_LL_DRIVER
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F0xx_HAL_Driver/Inc; ../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F0xx/Include; ../Drivers/CMSIS/Include; ../../src/3d/; ../../src/def/; ../../src/drv_stm32/; ../../src/lz4/; ../../src/synth/; ../../src/video/
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: generated.bin
  ILINK.IlinkOutputFile: generated.out
  ILINK.IlinkKeepSymbols: gau8SlidesPacked; gau8ObjectsPacked
  ILINK.IlinkIcfFile: stm32f030x6_flash.icf
  ILINK.IlinkExtraOptions: --image_input=../../src/artworks/teletext.packed,gau8SlidesPacked,readonly,2; --image_input=../../src/artworks/3dobjects.packed,gau8ObjectsPacked,readonly,2; --image_input=../../src/artworks/teletext2.packed,gau8Slides2Packed,readonly,2
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f030x6.s
  group Application/User
    ../Src/: dma.c gpio.c main.c spi.c stm32f0xx_it.c tim.c
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_ll_dma.c stm32f0xx_ll_exti.c stm32f0xx_ll_gpio.c stm32f0xx_ll_pwr.c stm32f0xx_ll_rcc.c stm32f0xx_ll_spi.c stm32f0xx_ll_tim.c stm32f0xx_ll_utils.c
  group src/3D_engine
    ../../src/3d/: renderer.c renderer.h
  group src/def
    ../../src/def/: consts.h platform.h types.h
  group src/drv_stm32
    ../../src/drv_stm32/: drv_video.c drv_video.h
  group src/lz4
    ../../src/lz4/: lz4.c lz4.h unlz4.h unlz4.S
  group src/video
    ../../src/video/: teletext.c teletext.h video.c video.h
